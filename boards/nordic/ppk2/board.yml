## boards/nordic/ppk2/board.yml
```yaml
board:
  name: ppk2
  full_name: PPK2
  vendor: nordic
  socs:
    - name: nrf52840
```
